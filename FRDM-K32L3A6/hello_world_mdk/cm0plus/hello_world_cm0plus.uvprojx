# Keil uVision project hello_world_cm0plus.uvprojx, settings and files
target hello_world_cm0plus (6180000::V6.18::ARMCLANG)
  device: K32L3A60VPJ1A:cm0plus NXP
  pack: NXP.K32L3A60_DFP.15.0.0
  cpu: CPUTYPE("Cortex-M0+")
  output: hello_world_cm0plus.out
  AfterMake: $K\ARM\ARMCLANG\bin\fromelf.exe --bincombined --bincombined_base=0x01000000 --output=$Lcore1_image.bin !L
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CPU_K32L3A60VPJ1A_cm0plus, MCMGR_HANDLE_EXCEPTIONS=1, __SEMIHOST_HARDFAULT_DISABLE=1, MULTICORE_APP=1, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..\middleware\multicore\mcmgr\src
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x1000000 size 0x40000
  memory RVCT9: RAM 0x9000000 size 0x20000
  scatter file: .\RTE\Device\K32L3A60VPJ1A_cm0plus\K32L3A60xxx_cm0plus_flash.scf
  link misc: --remove --entry=Reset_Handler
  group App
    ./: hello_world_core1.c
  group Documentation
    ./: readme.txt
  group mcmgr
    ../middleware/multicore/mcmgr/src/: mcmgr.c mcmgr_internal_core_api.h mcmgr_internal_core_api_k32l3a6.c mcmgr_mu_internal.c
software components: CMSIS:CORE 5.6.0, Board Support:SDK Project Template:project_template 1.0.0, Device:CMSIS:K32L3A60_header 1.0.0, Device:CMSIS:K32L3A60_system 1.0.0, Device:SDK Drivers:clock 2.2.1, Device:SDK Drivers:common 2.3.2, Device:SDK Drivers:gpio 2.6.0, Device:SDK Drivers:i2c 2.3.1, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:lpuart 2.5.3, Device:SDK Drivers:lpuart_adapter 1.0.0, Device:SDK Drivers:msmc 2.1.2, Device:SDK Drivers:mu 2.1.0, Device:SDK Drivers:port 2.3.0, Device:SDK Utilities:assert 1.0.0, Device:SDK Utilities:debug_console 1.0.1, Device:SDK Utilities:serial_manager 1.0.1, Device:SDK Utilities:serial_manager_uart 1.0.0, Device:Startup 1.1.0
